# Keil uVision project main.uvproj, settings and files
target game_python (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: STARTUP.A51 main.c
